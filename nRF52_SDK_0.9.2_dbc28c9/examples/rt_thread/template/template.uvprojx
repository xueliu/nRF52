# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-nrf52832 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF52
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf52832/Include;applications;.;drivers;../../../external/rt-thread/include;../../../external/rt-thread/libcpu/arm/cortex-m0;../../../external/rt-thread/libcpu/arm/common;../../../external/rt-thread/components/drivers/include;../../../external/rt-thread/components/finsh;..\..\..\components\drivers_nrf\hal
  asm define: NRF52, USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x800000 size 0x8000
  group Applications
    ./applications/: application.c startup.c
  group Drivers
    ./drivers/: board.c uart.c
  group Kernel
    ../../../external/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../external/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../external/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../external/rt-thread/components/drivers/src/: completion.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../external/rt-thread/components/finsh/: cmd.c msh.c msh_cmd.c shell.c symbol.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.0.5
