# Keil uVision project blinky_rtx_pca10036.uvprojx, settings and files
target nrf52832_xxac (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: OneElfS=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=1024 BSP_DEFINES_ONLY BOARD_PCA10036 RTX NRF52
  c misc: --c99
  c include: ..\..;..\..\..\..\bsp;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\external\rtx\include;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\inc\CMSIS\4.4.0
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Third Parties
    ../../: RTX_Conf_CM.c
    C:/Keil_v5/ARM/Pack/ARM/CMSIS/4.4.0/CMSIS/RTOS/RTX/LIB/ARM/: RTX_CM4.lib
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.5
