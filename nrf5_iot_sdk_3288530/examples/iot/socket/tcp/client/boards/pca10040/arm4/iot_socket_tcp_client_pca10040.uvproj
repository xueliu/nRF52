# Keil uVision project iot_socket_tcp_client_pca10040.uvproj, settings and files
target nrf52832_xxaa_s1xx_iot (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: __HEAP_SIZE=512 BLE_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx BSP_DEFINES_ONLY SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\..\components\iot\ble_ipsp;..\..\..\..\..\..\..\..\components\iot\common;..\..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\..\..\components\iot\errno;..\..\..\..\..\..\..\..\components\iot\medium;..\..\..\..\..\..\..\..\components\iot\socket\lwip;..\..\..\..\..\..\..\..\components\iot\socket\common;..\..\..\..\..\..\..\..\components\iot\socket\include;..\..\..\..\..\..\..\..\components\iot\socket\medium;..\..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers\nrf52;..\..\..\..\..\..\..\..\external\lwip\src\include;..\..\..\..\..\..\..\..\external\lwip\src\include\netif;..\..\..\..\..\..\..\..\external\lwip\src\include\lwip;..\..\..\..\..\..\..\..\external\lwip\src\port;..\..\..\..\..\..\..\..\external\lwip\src\port\arch;..\..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../../: main.c
    ../../../config/: sdk_config.h
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group lwIP
    ../../../../../../../../external/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../../../external/lwip/src/core/ipv6/: dhcp6.c icmp6.c inet6.c ip6.c ip6_addr.c mld6.c nd6.c
    ../../../../../../../../external/lwip/src/core/ipv4/: icmp.c ip4.c ip4_addr.c
    ../../../../../../../../external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_IoT
    ../../../../../../../../components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../../../../../components/iot/errno/: errno.c
    ../../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../../components/iot/medium/: ipv6_medium_ble.c
    ../../../../../../../../components/iot/common/: ipv6_parse.c
    ../../../../../../../../components/iot/socket/common/: mbuf.c portdb.c sleep.c socket.c
    ../../../../../../../../components/iot/socket/medium/: socket_medium.c
    ../../../../../../../../components/iot/socket/lwip/: transport_handler.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
