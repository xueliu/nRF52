# Keil uVision project iot_dfu_bootloader_dual_bank_app_s1xx_pca10040.uvproj, settings and files
target nrf52832_xxaa_s1xx (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s1xx +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SWI_DISABLE0 BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx BSP_DEFINES_ONLY SOFTDEVICE_PRESENT NRF52
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\iot\iot_dfu\common;..\..\..\..\..\..\components\iot\iot_dfu;..\..\..\..\..\..\components\iot\iot_dfu\bootloader;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\components\softdevice\s1xx_iot\headers\nrf52
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x7d000 size 0x2000
  memory RVCT9: RAM 0x20002c00 size 0xd400
  group Application
    ../../../: main.c
    ../../../config/: sdk_config.h
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_IoT
    ../../../../../../components/iot/iot_dfu/bootloader/: bootloader.c dfu_dual_bank.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/crc16/: crc16.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
