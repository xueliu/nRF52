# Keil uVision project iot_lwm2m_client_pca10040.uvproj, settings and files
target nrf52832_xxaa_s1xx_iot (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: __HEAP_SIZE=512 __STACK_SIZE=3072 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx SWI_DISABLE0 SOFTDEVICE_PRESENT NRF_TLS_MAX_INSTANCE_COUNT=2 MBEDTLS_CONFIG_FILE=<nrf_dtls_config.h> NRF52
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\components\iot\ble_ipsp;..\..\..\..\..\..\..\components\iot\coap;..\..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\..\components\iot\tls;..\..\..\..\..\..\..\components\iot\common;..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\components\iot\iot_timer;..\..\..\..\..\..\..\components\iot\ipv6_stack\pbuffer;..\..\..\..\..\..\..\components\iot\ipv6_stack\udp;..\..\..\..\..\..\..\components\iot\ipv6_stack\include;..\..\..\..\..\..\..\components\iot\ipv6_stack\utils;..\..\..\..\..\..\..\components\iot\ipv6_stack\icmp6;..\..\..\..\..\..\..\components\iot\lwm2m;..\..\..\..\..\..\..\components\iot\medium;..\..\..\..\..\..\..\components\iot\medium\ble_ncfgs;..\..\..\..\..\..\..\components\iot\medium\include;..\..\..\..\..\..\..\components\iot\medium\commissioning;..\..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\..\components\iot\tls\mbedtls\dtls\config;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers\nrf52;..\..\..
  asm define: __HEAP_SIZE=512 __STACK_SIZE=3072 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET s1xx SWI_DISABLE0 SOFTDEVICE_PRESENT NRF_TLS_MAX_INSTANCE_COUNT=2 NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../../: addr_parse.c main.c
    ../../../config/: sdk_config.h
  group Board Support
    ../../../../../../bsp/: bsp.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_IoT
    ../../../../../../../components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../../../../components/iot/coap/: coap.c coap_message.c coap_option.c coap_queue.c coap_resource.c coap_transport_dtls.c
    ../../../../../../../components/iot/ipv6_stack/icmp6/: icmp6.c
    ../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../components/iot/ipv6_stack/pbuffer/: iot_pbuffer.c
    ../../../../../../../components/iot/iot_timer/: iot_timer.c
    ../../../../../../../components/iot/lwm2m/: ipso_objects.c ipso_objects_tlv.c lwm2m.c lwm2m_bootstrap.c lwm2m_coap_util.c lwm2m_objects.c lwm2m_objects_tlv.c lwm2m_register.c lwm2m_tlv.c
    ../../../../../../../components/iot/ipv6_stack/ipv6/: ipv6.c
    ../../../../../../../components/iot/medium/: ipv6_medium_ble.c
    ../../../../../../../components/iot/common/: ipv6_parse.c
    ../../../../../../../components/iot/ipv6_stack/utils/: ipv6_utils.c
    ../../../../../../../components/iot/ipv6_stack/udp/: udp6.c
  group nRF_IoT_Commissioning
    ../../../../../../../components/iot/medium/ble_ncfgs/: ble_ncfgs.c
    ../../../../../../../components/iot/medium/commissioning/: commissioning.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_TLS
    ../../../../../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    ../../../../../../../components/iot/tls/mbedtls/: tls_interface.c
