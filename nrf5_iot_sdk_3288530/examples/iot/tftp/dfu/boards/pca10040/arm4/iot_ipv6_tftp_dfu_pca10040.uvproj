# Keil uVision project iot_ipv6_tftp_dfu_pca10040.uvproj, settings and files
target nrf52832_xxaa_s1xx_iot (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=512 ENABLE_DEBUG_LOG_SUPPORT PSTORAGE_USED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET BLE_STACK_SUPPORT_REQD s1xx SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\components\iot\ble_ipsp;..\..\..\..\..\..\..\components\iot\common;..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\components\iot\iot_dfu\common;..\..\..\..\..\..\..\components\iot\iot_dfu;..\..\..\..\..\..\..\components\iot\iot_dfu\app;..\..\..\..\..\..\..\components\iot\iot_file;..\..\..\..\..\..\..\components\iot\iot_file\pstorage_raw;..\..\..\..\..\..\..\components\iot\iot_file\static;..\..\..\..\..\..\..\components\iot\iot_timer;..\..\..\..\..\..\..\components\iot\ipv6_stack\pbuffer;..\..\..\..\..\..\..\components\iot\ipv6_stack\udp;..\..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\..\components\iot\ipv6_stack\include;..\..\..\..\..\..\..\components\iot\ipv6_stack\utils;..\..\..\..\..\..\..\components\iot\ipv6_stack\icmp6;..\..\..\..\..\..\..\components\iot\ipv6_stack\tftp;..\..\..\..\..\..\..\components\iot\medium;..\..\..\..\..\..\..\components\iot\medium\ble_ncfgs;..\..\..\..\..\..\..\components\iot\medium\include;..\..\..\..\..\..\..\components\iot\medium\commissioning;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers\nrf52;..\..\..\..\..\..\..\external\cJSON;..\..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0xd800
  group Application
    ../../../: main.c
    ../../../config/: sdk_config.h
  group Board Support
    ../../../../../../bsp/: bsp.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group Third Parties
    ../../../../../../../external/cJSON/: cJSON.c cJSON_iot_hooks.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_IoT
    ../../../../../../../components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../../../../components/iot/ipv6_stack/icmp6/: icmp6.c
    ../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../components/iot/iot_file/: iot_file.c
    ../../../../../../../components/iot/iot_file/pstorage_raw/: iot_file_pstorage_raw.c
    ../../../../../../../components/iot/iot_file/static/: iot_file_static.c
    ../../../../../../../components/iot/ipv6_stack/pbuffer/: iot_pbuffer.c
    ../../../../../../../components/iot/ipv6_stack/tftp/: iot_tftp.c
    ../../../../../../../components/iot/iot_timer/: iot_timer.c
    ../../../../../../../components/iot/ipv6_stack/ipv6/: ipv6.c
    ../../../../../../../components/iot/medium/: ipv6_medium_ble.c
    ../../../../../../../components/iot/common/: ipv6_parse.c
    ../../../../../../../components/iot/ipv6_stack/utils/: ipv6_utils.c
    ../../../../../../../components/iot/ipv6_stack/udp/: udp6.c
  group nRF_IoT_Commissioning
    ../../../../../../../components/iot/medium/ble_ncfgs/: ble_ncfgs.c
    ../../../../../../../components/iot/medium/commissioning/: commissioning.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/iot/iot_dfu/app/: iot_dfu.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
