# Keil uVision project blinky_blank_pca10036.uvprojx, settings and files
target nrf52832_xxaa (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET NRF52
  c misc: --c99
  c include: ..\..\..;..\..\..\..\..\bsp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\FreeRTOS_v8.2.2\include;..\..\..\..\..\..\FreeRTOS_v8.2.2\Common\include;..\..\..\..\..\..\FreeRTOS_v8.2.2\portable\RVDS\ARM_CM4F
  asm define: as above
  asm include: ..\..\..\..\..\..\FreeRTOS_v8.2.2\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group FreeRTOS
    ../../../../../../FreeRTOS_v8.2.2/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../FreeRTOS_v8.2.2/portable/MemMang/: heap_2.c
    ../../../../../../FreeRTOS_v8.2.2/include/: FreeRTOSConfig.h
  group ARM_CM4F
    ../../../../../../FreeRTOS_v8.2.2/portable/RVDS/ARM_CM4F/: port.c portmacro.h
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
